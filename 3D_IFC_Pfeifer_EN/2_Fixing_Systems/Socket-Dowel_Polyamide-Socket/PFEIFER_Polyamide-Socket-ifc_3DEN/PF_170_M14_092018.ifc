Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverAddonView, ConceptDesignBIM_2010], ExchangeRequirement[Architecture]
File name: K:\PSH-BT\ZEICH\0000_PFEIFER-CAD-Bibliothek\2D_3D_Extern_Internet\3D_IFC-2018_Pfeifer_DE\2_Befestigungstechnik\Huelsenduebel_Polyhuelsen\170_Polyhuelse\PF_170_M14_102015.ifc
Time: 2018-09-12T14:00:41
Author: gast_btke
Written by: EXPRESS Data Manager stand alone and remote client system - Version 5.00.0310.07.32mod Sep 15 2011
Made in: AutoCAD Architecture 2018 - Deutsch (German) Build 8.0.44.0

# IfcProject, 1
LongName: Pfeifer
ADT_Pset_DISPLAY_SET - ACA_DISPLAY_CONFIG_ON_EXPORT: Standard; ACA_DISPLAY_SET_ON_EXPORT: Modell

# IfcBuilding, Pfeifer
ElevationOfRefHeight: 0 mm; ElevationOfTerrain: 0 mm
Pset_BuildingCommon - IsPermanentID: no; SprinklerProtection: no; SprinklerProtectionAutomatic: no; GrossPlannedArea: 0 m2; NumberOfStoreys: 0; IsLandmarked: no
Pset_BuildingUse - VacancyRateInCategoryNow: 0; VacancyRateInCategoryFuture: 0
Pset_BuildingWaterStorage - WaterStorageRatePerPerson: 0 m3; OneDayPotableWater: 0 m3; OneDayEssentialWater: 0 m3; OneDayCoolingTowerMakeupWater: 0 m3; OneDayProcessOrProductionWater: 0 m3
ePset_BuildingEnergyTarget - BuildingEnergyTargetValue: 0
